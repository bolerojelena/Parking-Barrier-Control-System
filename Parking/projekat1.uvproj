# Keil uVision project projekat1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: projekat1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c tipovi.h gpio.h gpio.c timer.h timer.c prekidi.h prekidi.c serijska_komunikacija.h serijska_komunikacija.c cobs_protokol.h cobs_protokol.c display.h display.c poruka.h poruka.c
